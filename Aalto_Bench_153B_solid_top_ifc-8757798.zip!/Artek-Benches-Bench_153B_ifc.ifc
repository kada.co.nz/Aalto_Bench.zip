Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-11-23T01:35:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 23 01:35:44 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\4cd241f8-d850-4ce6-8a37-90f0a535371d\3320cb72-a043-4a86-b1a2-0b9646e22c40\ifc * Database version: 5507 * Database creation date: Thu Nov 23 01:35:44 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 23 01:35:44 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 23 01:35:44 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Bench 153B, Artek-Benches-Bench_153B_rfa:Bench 153B:434140
In: Level 1
Type - Material: Natural laquered
Type - Constraints - Default Elevation: 0 mm
Type - General - Author: BIMstone; BIMObjectName: Artek-Benches-Bench_153B; ManufacturerName: Artek; ManufacturerURL: https://www.artek.fi/; NBSDescription: Benches; NBSReference: 45-35-86/321; ProductInformation: Bench 153 is lightweight, versatile, and equally at home in the public and private spheres. The seat is composed of solid birch wood and features vertical recesses that make the bench light and easy to move.; Revision: n/a; Uniclass2: Pr_40_50_12; Uniclass2015Description: Chairs, seats and benches; Uniclass2015Reference: Pr_40_50_12; Version: 1; VersionDate: 15/11/2023
Type - Identity Data - Cost: 0; Description: Bench 153 is lightweight, versatile, and equally at home in the public and private spheres. The seat is composed of solid birch wood and features vertical recesses that make the bench light and easy to move.; Designer: Alvar Aalto, 1945; Manufacturer: Artek; Model: Bench 153B; OmniClass Number: 23.40.20.14.17.11; OmniClass Title: Dining Room Tables; ProductDatasheet: https://www.artek.fi/downloads/Bench-153-Factsheet-1843342.pdf; Type Name: Bench 153B; URL: https://www.artek.fi/en/products/bench-153
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Artek; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Artek-Benches-Bench_153B_rfa; Features: n/a; Finish: The seat is composed of solid birch wood and features vertical recesses that make the bench light and easy to move.; Grade: n/a; Material: Wood and laminate; ModelNumber: n/a; ModelReference: n/a; Name: Bench_153B; ReplacementCost: n/a; Shape: Sculptured; Size: 725x400x440 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Artek
Type - Pset_ProductRequirements - Name: Bench_153B; Category: Furniture
Type - Pset_QuantityTakeOff - Reference: Bench 153B
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.788375 m2; Volume: 0.12847 m3
Materials and Finishes - TableMainMaterial: Natural laquered
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Artek-Benches-Bench_153B_rfa: Bench 153B; Family and Type: Artek-Benches-Bench_153B_rfa: Bench 153B; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Artek-Benches-Bench_153B_rfa: Bench 153B; Type Id: Artek-Benches-Bench_153B_rfa: Bench 153B; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
